# Keil uVision project CD4094_7segment.uvproj, settings and files
target 7segment_CD4094 (MCS-51)
  device: AT89C52 Microchip
  cpu: IRAM(0-0xFF) IROM(0-0x1FFF) CLOCK(24000000)
  output: CD4094_7segment +hex
  c flags: Optimize=8 SizeSpeed=1
  c include: .\Main;.\User
  group Main
    ./Main/: main.c
  group User
    ./User/: CD4094.c
